# Keil uVision project led.uvprojx, settings and files
target led (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SC32F12TS8 SinOneMicroelectronics
  pack: SinOne.SC32F1xxx_DFP.1.1.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SC32f12xx,PrintfEable
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\User;..\Drivers;..\Apps;..\CMSIS;..\Algorithm
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../User/: main.c system_sc32f1xxx.c SC_it.c SC_Init.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c Utils.c Utils.h
  group Apps
    ../Apps/: LED.c LED.h Key.c Key.h Serial.c Serial.h Weight.c Weight.h Dalay.c Delay.h OLED.c OLED.h OLED_Font.h Voice.c Voice.h HX711.c HX711.h
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_led.c sc32f1xxx_option.c sc32f1xxx_rcc.c sc32f1xxx_gpio.c sc32f1xxx_op.c sc32f1xxx_adc.c sc32f1xxx_uart.c sc32f1xxx_tim.c
  group Startup
    ./: startup_sc32f12xx.s
  group Algorithm
    ../Algorithm/: Filter.c Filter.h
